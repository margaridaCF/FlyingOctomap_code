Commit message: Velodyne on the top and PCL converter (not working - node crashes)

File: architecture/Tools/iris_base.urdf (robot description, URDF)
Before this commit: robot iris, 9 links, 8 joints
Joints:
- joint velodyne_base_mount_joint: origin xyz=0 0 1 rpy=0 0 0 -> xyz=0 0 0.04 rpy=0 0 0
